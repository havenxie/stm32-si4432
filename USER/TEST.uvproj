# Keil uVision project TEST.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TEST +hex
  c flags: Optim=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\FLASH;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\NRF24L01;..\HARDWARE\SD;..\HARDWARE\REMOTE;..\HARDWARE\DS18B20;..\STM32F10x;..\HARDWARE\OLED;..\HARDWARE\SI4432;..\HARDWARE\SPI;..\USMART
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/WKUP/: wkup.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
    ../HARDWARE/SPI/: spi.c spi2.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/SI4432/: si4432.c
  group DOC
    ../: README.TXT
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
